# Autodesk Inventor assembly: LSVA50-M10X68.x_
Saved by Autodesk Inventor 2022.5 (Build 265521000, 521)
## iProperties
Created: 2024-08
Part Number: LSVA50-M10X68.x_
Document SubType Name: Assembly
Designer: ImaoCorp
Author: ImaoCorp
Sending System: SOLIDWORKS 2022-2022290
MC: AMD64
MC_MODEL: Intel64 Family 6 Model 60 Stepping 3, GenuineIntel
OS: Windows_NT
FRU: Parasolid Version 33.1, build 260,  4-25-2022
FORMAT: text
GUISE: transmit
KEY: FILELSVA50-M10X68.x_t
DATE: Fri Aug 23 16:08:09 2024
## Documents named in this file (4)
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva50-m10x68\LSVA50-M10X68.x_.iam
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva50-m10x68\LSVA50-M10X68_01.ipt
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva50-m10x68\LSVA50-M10X68_02.ipt
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva50-m10x68\LSVA50-M10X68_03.ipt
## Components (3 placed, 3 different names)
1. LSVA50-M10X68_01
2. LSVA50-M10X68_02
3. LSVA50-M10X68_03
